# Keil uVision project CppTemplate.uvprojx, settings and files
target CppTemplate (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CppTemplate
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1,ARM_MATH_CM4,ARM_MATH_LOOPUNROLL
  c include: Core\Inc;Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;Middlewares\Third_Party\FreeRTOS\Source\include;Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;User\Alog\inc;User\cmsis;User\control\inc;User\config\inc;User\device\inc;User\drive\inc;User\Matrix_Robotics\src;User\motor\inc;User\my_task\inc;User\protocol\inc;Drivers\CMSIS\DSP\Include;Drivers\CMSIS\DSP\Include\dsp;User\controler\inc;User\Imu\inc;MDK-ARM\RTE\_CppTemplate;User\module\inc;User\Alog\eigen3
  asm define: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group USER/IMU/SRC
    User/Imu/src/: BMI.c bmi2.c bmi270.c common.c
  group USER/MIAN
    User/mian/: main.cpp
  group USER/MODULE/SRC
    User/module/src/: chassis_motor.cpp gimbal_motor.cpp manipulator_motor.cpp
  group protocol
    User/protocol/src/: crc.cpp imu_protocol.c pubsub.cpp uart_protocol.cpp
  group mytask
    User/my_task/src/: robot_task.cpp
  group Motor
    User/motor/src/: dji_motor.cpp lk_motor.cpp motor.cpp
  group Middlewares/FreeRTOS
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers
    User/drive/src/: driver_can.cpp driver_haltick.cpp driver_spi.cpp driver_uart.cpp driver.cpp
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    Core/Src/: system_stm32f4xx.c
  group Device
    User/device/src/: device.cpp imu_sensor.c remote.cpp
  group Device/imu
    User/Imu/src/: common.c bmi270.c bmi2.c BMI.c
    User/Imu/inc/: bmi2_defs.h
  group controler
    User/controler/src/: pid.cpp
  group control
    User/control/src/: robot.cpp
  group CMSIS/DSP
    Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
  group Application/User/Core
    Core/Src/: can.c dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tim.c usart.c
  group Application/MDK-ARM
    MDK-ARM/: startup_stm32f407xx.s
  group Alog
    User/Alog/src/: ave_filter.cpp heart_beat.cpp matrix.cpp robotics.cpp utils.cpp
