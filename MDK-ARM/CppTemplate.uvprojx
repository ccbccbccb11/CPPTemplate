# Keil uVision project CppTemplate.uvprojx, settings and files
target CppTemplate (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CppTemplate +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1,ARM_MATH_CM4,ARM_MATH_LOOPUNROLL
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Alog/inc;../User/cmsis;../User/control/inc;../User/config/inc;../User/device/inc;../User/drive/inc;../User/Entity/inc;../User/Matrix_Robotics/src;../User/motor/inc;../User/my_task/inc;../User/protocol/inc;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../User/controler/inc;../User/Imu/inc;../User/Alog/eigen3;../User/module/inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../User/mian/: main.cpp
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Alog
    ../User/Alog/src/: utils.cpp matrix.cpp robotics.cpp ave_filter.cpp heart_beat.cpp
  group Drivers
    ../User/drive/src/: driver.cpp driver_can.cpp driver_uart.cpp driver_haltick.cpp driver_spi.cpp
  group Motor
    ../User/motor/src/: dji_motor.cpp lk_motor.cpp motor.cpp
  group Device/imu
    ../User/Imu/src/: BMI.c bmi2.c bmi270.c common.c
    ../User/Imu/inc/: bmi2_defs.h
  group Device
    ../User/device/src/: device.cpp remote.cpp imu_sensor.c
  group protocol
    ../User/protocol/src/: uart_protocol.cpp crc.cpp imu_protocol.c pubsub.cpp
  group module
    ../User/module/src/: chassis.cpp
  group controler
    ../User/controler/src/: pid.cpp
  group mytask
    ../User/my_task/src/: robot_task.cpp
  group CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
